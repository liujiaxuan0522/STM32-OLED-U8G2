# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: Libraries\CMSIS;Libraries\StdPeriph\inc;User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    Libraries/CMSIS/: startup_stm32f10x_md.s
  group CMSIS
    Libraries/CMSIS/: system_stm32f10x.c
  group StdPeriph_Driver
    Libraries/StdPeriph/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group User
    User/: delay.c font_ascii.c font_cn.c main.c oled.c soft_i2c.c
